Commit message: Initial benchmarks vs other solvers

File: examples/assets/urdf/double_pendulum/pendubot_cont.urdf (robot description, URDF)
Before this commit: robot double_pendulum, 6 links, 5 joints
Joints:
- joint joint2: limit effort=0.0 velocity=35 -> effort=0 velocity=35
